# Keil uVision project LCD Test.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LCD Test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s system_LPC11xx.c
  group New Group
    ./: main.c
  group driver
    ./msp430-lcd-master/: driverTester.c lcd.c lcd.h lcd_config.h
